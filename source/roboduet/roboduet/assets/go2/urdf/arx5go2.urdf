Commit message: urdf fix 最后俩关节

File: source/roboduet/roboduet/assets/go2/urdf/arx5go2.urdf (robot description, URDF)
Before this commit: robot go2_description, 37 links, 36 joints
Joints:
- joint zarx_j7: type prismatic -> fixed
- joint zarx_j8: type prismatic -> fixed
